# Keil uVision project hexapode.uvproj, settings and files
target Hexapode (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: hexapode
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4 OneElfS=1
  c define: CORE_M3
  c include: ..\lpcopen\software\lpc_core\lpc_chip\chip_17xx_40xx;..\lpcopen\software\lpc_core\lpc_ip;..\lpcopen\software\lpc_core\lpc_chip\chip_common;..\lpcopen\software\lpc_core\lpc_board\board_common;..\lpcopen\software\freertos\freertos\Source\include;..\lpcopen\software\freertos\freertos\Source\portable\RVDS\ARM_CM3;.\include;..\lpcopen\software\lpc_core\lpc_board\boards_17xx_40xx\lpc1766stk
  asm define: CORE_M3
  asm misc: --cpreproc
  asm include: ..\lpcopen\software\lpc_core\lpc_board\boards_17xx_40xx\lpc1766stk
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group main
    ./src/: main.c servomoteur.c tor.c telemetre.c basic_io.c Hexapode.c Protopode.c
    ../lpcopen/software/freertos/startup_code/: keil_freertos_startup_lpc17xx40xx.s
  group FreeRTOS_17xx
    ../lpcopen/software/freertos/freertos/Source/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS
    ../lpcopen/software/freertos/freertos/Source/: croutine.c list.c queue.c timers.c tasks.c
    ../lpcopen/software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../lpcopen/software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
  group board
    ../lpcopen/software/lpc_core/lpc_board/boards_17xx_40xx/lpc1766stk/: board_LPC1766STK.c sysinit_LPC1766STK.c
  group lpcopen_chip
    ../lpcopen/software/lpc_core/lpc_chip/chip_17xx_40xx/: adc_17xx_40xx.c clock_17xx_40xx.c iocon_17xx_40xx.c ritimer_17xx_40xx.c timer_17xx_40xx.c uart_17xx_40xx.c sysctl_17xx_40xx.c
  group lpcopen_ip
    ../lpcopen/software/lpc_core/lpc_ip/: adc_001.c atimer_001.c fpu_init.c gpio_003.c gpiogrpint_001.c gpioint_001.c gpiopinint_001.c ritimer_001.c timer_001.c usart_001.c usart_002.c
  group lpcopen_common
    ../lpcopen/software/lpc_core/lpc_chip/chip_common/: mem_tests.c ring_buffer.c
